# Keil uVision project OR_code_detector.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: lcd +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\User;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32E23x\Include;..\Firmware\GD32E23x_standard_peripheral\Include;..\Hardware\lcd;..\Hardware\OV2640;..\Hardware\SPI;..\Hardware\TIMER;..\Hardware\TPAD;..\Firmware\CMSIS\Core
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Doc
    ../Doc/: readme.txt
  group Firmware
    ../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group User
    ../User/: gd32e23x_it.c main.c systick.c
  group Hardware
    ../Hardware/lcd/: lcd.c lcd_init.c lcd.h lcd_init.h lcdfont.h
    ../Hardware/OV2640/: ov2640.c sccb.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
    ../Firmware/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
software components: CMSIS:CORE 5.6.0
